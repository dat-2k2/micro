# Keil uVision project TimerSplash.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F207IGHx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.10.0
  cpu: IROM(0x08000000,0x00100000) IRAM(0x20000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TimerSplash
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./: lab6.c
software components: CMSIS:CORE 5.6.0, Device:STM32Cube Framework:Classic 1.2.7, Device:STM32Cube HAL:Common 1.2.7, Device:STM32Cube HAL:Cortex 1.2.7, Device:STM32Cube HAL:DMA 1.2.7, Device:STM32Cube HAL:EXTI 1.2.7, Device:STM32Cube HAL:Flash 1.2.7, Device:STM32Cube HAL:GPIO 1.2.7, Device:STM32Cube HAL:RCC 1.2.7, Device:STM32Cube HAL:RTC 1.2.7, Device:STM32Cube HAL:TIM 1.2.7, Device:Startup 2.2.1
